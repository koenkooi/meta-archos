require gcc-cross-initial_${PV}.bb
require recipes-devtools/gcc/gcc-cross-kernel.inc
